options:
  parameters:
    author: Otniel Marquina, Andrés Velasquez
    generate_options: qt_gui
    id: Mision6
    output_language: python
    title: Nuestra Propia Emisora FM
  states: {}

blocks:
- name: AudioRate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: Channel_Rate
  id: variable_qtgui_range
  parameters:
    start: 88e6
    step: 100e3
    stop: 108e6
    value: 89.5e6
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6/64
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.01'
    freq: '19000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: 4*int(samp_rate)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: AudioRate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '20'
    high_cutoff_freq: 40e3
    low_cutoff_freq: 36e3
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/estudiante/Música/Canned Heat (Remastered 2006).wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 15e3
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    gain: '1'
    interp: '1'
    samp_rate: 4*samp_rate
    type: interp_fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '15000'
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    nconnections: '6'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: 4*samp_rate
    fc: Channel_Rate
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '6'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: AudioRate
    interp: int(samp_rate)
    type: fff
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: AudioRate
    interp: int(samp_rate)
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Channel_Rate
    gain0: GTX
    samp_rate: 4*samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: L
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: R
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Piloto
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: MPX
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_sink_4_0
  id: virtual_sink
  parameters:
    stream_id: L-R_38k
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: L
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: R
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: L+R
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: L-R_38k
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: L-R
  states: {}
- name: virtual_source_5_1
  id: virtual_source
  parameters:
    stream_id: L-R_38k
  states: {}
- name: virtual_source_5_2
  id: virtual_source
  parameters:
    stream_id: MPX
  states: {}
- name: virtual_source_5_2_0
  id: virtual_source
  parameters:
    stream_id: MPX
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: Piloto
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: Piloto
  states: {}
- name: virtual_source_6_1
  id: virtual_source
  parameters:
    stream_id: Piloto
  states: {}

connections:
- [analog_sig_source_x_0, '0', virtual_sink_2, '0']
- [analog_wfm_tx_0, '0', low_pass_filter_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_5, '0']
- [blocks_add_xx_1, '0', virtual_sink_3, '0']
- [blocks_multiply_xx_0_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0, '0', virtual_sink_4_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_4, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '1', audio_sink_0, '1']
- [blocks_wavfile_source_0, '1', rational_resampler_xxx_1, '0']
- [low_pass_filter_0, '0', virtual_sink_1, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0_0, '0', uhd_usrp_sink_0, '0']
- [low_pass_filter_1, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_1, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_1, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_2, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', blocks_sub_xx_0, '0']
- [virtual_source_3, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', blocks_sub_xx_0, '1']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_4, '0', qtgui_time_sink_x_0, '3']
- [virtual_source_4_0, '0', blocks_add_xx_1, '0']
- [virtual_source_5, '0', qtgui_freq_sink_x_0, '4']
- [virtual_source_5, '0', qtgui_time_sink_x_0, '4']
- [virtual_source_5_0, '0', blocks_multiply_xx_0_0_0, '0']
- [virtual_source_5_1, '0', blocks_add_xx_1, '2']
- [virtual_source_5_2, '0', qtgui_freq_sink_x_0, '5']
- [virtual_source_5_2, '0', qtgui_time_sink_x_0, '5']
- [virtual_source_5_2_0, '0', analog_wfm_tx_0, '0']
- [virtual_source_6, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_6, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_6_0, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_6_0, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_6_1, '0', blocks_add_xx_1, '1']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
